# Keil uVision project Cloud_Home.uvprojx, settings and files
target Cloud_Home (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Cloud_Home +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CODE;..\USER;..\STM32F10x_FWLib\inc;..\MYCODE\LED;..\MYCODE\BEEP;..\MYCODE\KEY;..\MYCODE\USART;..\SYSTEM\SYS;..\MYCODE\ESP8266;..\SYSTEM\SYSTICK;..\SYSTEM\delay;..\MYCODE\NRF24L01;..\MYCODE\TIM3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group MYCODE
    ../MYCODE/LED/: led.c
    ../MYCODE/BEEP/: beep.c
    ../MYCODE/KEY/: key.c
    ../MYCODE/USART/: usart.c usart2.c
    ../MYCODE/ESP8266/: esp8266.c esp8266_Config.c
    ../MYCODE/TIM3/: tim3.c
    ../MYCODE/NRF24L01/: nRF24L01_API.c
  group CODE
    ../CODE/: startup_stm32f10x_xl.s
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
