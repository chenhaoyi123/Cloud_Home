# Keil uVision project 2.4G+bh1750+dht11.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: C8T6 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CODE;..\LIB\inc;..\MYCODE\LED;..\MYCODE\SYS;..\MYCODE\SYSTICK;..\MYCODE\USART;..\MYCODE\NRF24L01;..\MYCODE\SG90_PWM;..\MYCODE\HB1750_I2C;..\MYCODE\DTH11;..\MYCODE\TIM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CODE
    ../CODE/: core_cm3.c startup_stm32f10x_md.s
  group LIB
    ../LIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group MYCODE
    ../MYCODE/LED/: led.c
    ../MYCODE/SYSTICK/: systick.c
    ../MYCODE/USART/: usart.c
    ../MYCODE/NRF24L01/: nRF24L01_API.c
    ../MYCODE/SG90_PWM/: sg90_pwm.c
    ../MYCODE/HB1750_I2C/: bh1750.c i2c.c
    ../MYCODE/DTH11/: dht11.c
    ./: t.txt
    ../MYCODE/TIM3/: tim3.c
